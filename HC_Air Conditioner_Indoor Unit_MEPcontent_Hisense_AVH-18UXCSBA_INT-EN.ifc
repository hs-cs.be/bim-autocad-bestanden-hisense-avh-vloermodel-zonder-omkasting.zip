Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2018-03-13T11:31:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.0.428.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 13 11:31:05 2018 * Host: B3ROBRAWR2599 * Database: C:\Users\APOP\AppData\Local\Temp\{0FA9850C-F721-48F1-8926-EB8A74CE4300}\ifc * Database version: 5507 * Database creation date: Tue Mar 13 11:31:05 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue Mar 13 11:31:05 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 13 11:31:05 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcUnitaryEquipment: AVH-18UXCSBA, HC_Air Conditioner_Indoor Unit_MEPcontent_Hisense_AVH-08-24_INT-EN:AVH-18UXCSBA:1293641
In: V00
Type - PredefinedType: AIRCONDITIONINGUNIT; Material: Color RGB 166-166-166, Color RGB 168-124-048, Color RGB 075-075-075
Type - Dimensions - Depth: 202 mm; Drain Diameter: 32 mm; Duct Depth: 109 mm; Duct Width: 939 mm; Height: 619 mm; Refrigerant Gas Diameter: 15.9 mm; Refrigerant Liquid Diameter: 6.35 mm; Width: 1168 mm
Type - Electrical - Hertz: 50 Hz; Phase: 1; Voltage: 230 V
Type - Identity Data - Article Description: Floor concealed type; Article Type: AVH-18UXCSBA; Content Supplier URL: www.mepcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: Floor concealed type; EMCS Version: 3.0; ETIM Article Class: EC000403; Family Version: 11.13; Manufacturer: Hisense; Manufacturer Art. No.: AVH-18UXCSBA; Manufacturer URL: http://www.hs-cs.nl/; MEPcontent Class: AIR_CONDITIONER_INDOOR_UNIT; Model: AVH-18UXCSBA; OmniClass Number: 23.75.10.24.21.27; OmniClass Title: Unitary Air Conditioning Equipment; Product Line: AVH Series; Revit Version: 2016; Type Name: AVH-18UXCSBA; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Dark Grey: Color RGB 075-075-075; Grey: Color RGB 166-166-166; Yellow: Color RGB 168-124-048
Type - Mechanical - Loads - Airflow Rate (m3/min): 14.83; Cooling Capacity (kW): 5.6; External Static Pressure (Pa): 0; Heating Capacity (kW): 6.5; Motor Power: 90; Sound Pressure Level (dB(A)): 32; Unit Weight (kg): 26
Type - Other - Category: Mechanical Equipment; a: 1424 mm; b: 1218 mm; c: 939 mm; Family Name: HC_Air Conditioner_Indoor Unit_MEPcontent_Hisense_AVH-08-24_INT-EN; Refrigerant Gas Radius: 7.95 mm; Refrigerant Liquid Radius: 3.175 mm; Refrigerant Type: R410A
Pset_ManufacturerTypeInformation - Manufacturer: Hisense
Constraints - Offset: 0 mm
Dimensions - Area: 4.74163 m2; Volume: 0.681697 m3
Electrical - Loads - Power: 0 W
Identity Data - Design Option: Main Model; Mark: 4
Mechanical - System Classification: Power,Hydronic Supply,Sanitary,Supply Air
Mechanical - Flow - Air Outlet Flow: 0 m3/s; Drain Fixture Units: 0; Refrigerant Gas Flow: 0 m3/s; Refrigerant Liquid Flow: 0 m3/s
Other - Back Clearance Safe: 0 mm; Bottom Clearance Safe: 0 mm; Family: HC_Air Conditioner_Indoor Unit_MEPcontent_Hisense_AVH-08-24_INT-EN: AVH-18UXCSBA; Family and Type: HC_Air Conditioner_Indoor Unit_MEPcontent_Hisense_AVH-08-24_INT-EN: AVH-18UXCSBA; Front Clearance Safe: 0 mm; Left Clearance Safe: 240 mm; Right Clearance Safe: 240 mm; Top Clearance Safe: 1000 mm; Type: HC_Air Conditioner_Indoor Unit_MEPcontent_Hisense_AVH-08-24_INT-EN: AVH-18UXCSBA; Type Id: HC_Air Conditioner_Indoor Unit_MEPcontent_Hisense_AVH-08-24_INT-EN: AVH-18UXCSBA
Phasing - Phase Created: 4. Plan over 10 jaar
Visibility - Back Clearance: 0 mm; Bottom Clearance: 0 mm; Front Clearance: 0 mm; Left Clearance: 240 mm; Right Clearance: 240 mm; Service Space: no; Top Clearance: 1000 mm
